# Keil uVision project Test.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: nRF5340_xxAA:Application Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x0003F000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x08000000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Test
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x3f000
  group User Application
    ./: main.c
software components: CMSIS:CORE 5.1.2, Device:Startup 8.44.1
